# Keil uVision project lab3a_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3a_demo
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Keil_v5\ARM\RV31\INC;.\USB Audio API;.\Images;..\MediaCentre-bf-onsite
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group utility
    ./: Font_6x8_h.h Font_16x24_h.h GLCD_SPI_LPC1700.c LED.c LED.h KBD.c KBD.h GLCD.h
  group main
    ./: main.c
  group audio interface
    ./USB Audio API/: usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c adcuser.c nowplaying.c
  group Photo Viewer
    ./: PhotoViewer.c
    ./Images/: anos.c giorno.c goku.c kaido.c saitama.c
  group snake
    ./: snake.c
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
